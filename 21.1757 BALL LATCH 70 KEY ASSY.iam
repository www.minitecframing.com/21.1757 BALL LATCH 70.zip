# Autodesk Inventor assembly: 21.1757 BALL LATCH 70 KEY
## iProperties
Created: 2007-07
Part Number: 21.1757 BALL LATCH 70 KEY
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
