# Autodesk Inventor assembly: 21.1757 BALL LATCH 70
## iProperties
Created: 2007-03
Part Number: 21.1757 BALL LATCH 70
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
